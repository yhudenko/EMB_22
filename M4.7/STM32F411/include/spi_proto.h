// ============================================================================
// Спільний протокол ESP32 (SPI master) <-> STM32 (SPI slave).
// Файл ІДЕНТИЧНИЙ в обох проєктах: змінюєте тут - копіюйте в інший.
// ============================================================================
//
// ЧОМУ ПОТРІБЕН ПРОТОКОЛ
// SPI передає просто байти: він не знає, де початок/кінець повідомлення, чи
// дійшли дані без помилок і чи їх обробили. Усе це ми додаємо самі: розмір
// кадру, magic-байти, номер кадру (seq), контрольну суму (CRC) і статус.
//
// ГОЛОВНА ОСОБЛИВІСТЬ SPI: ПОВНИЙ ДУПЛЕКС
// Master тактує лінію SCK; на кожному такті master виставляє біт на MOSI, а
// slave ОДНОЧАСНО виставляє біт на MISO. Тобто під час відправки 64 байтів
// master завжди отримує 64 байти у відповідь. Але slave мусить мати цю
// відповідь ГОТОВОЮ ДО початку транзакції - він не може "прочитати запит і
// тут же відповісти на нього". Звідси схема нижче.
//
// ЯК ПРАЦЮЄ ОБМІН (одна відправка запису)
//
//   Master (ESP32)                         Slave (STM32)
//   --------------                         -------------
//   1. кадр DATA (рядок даних)  ------->   приймає; у відповідь на цей кадр
//                               <-------   іде СТАРИЙ статус (ігноруємо)
//                                          обробляє: перевіряє CRC, пише на
//                                          SD, оновлює статус, готує нову
//                                          відповідь
//   2. пауза ~20 мс (час на SD)
//   3. кадр POLL (порожній)     ------->   приймає
//                               <-------   відповідь = СВІЖИЙ статус DATA
//   4. master перевіряє: last_seq == мій seq і status == ST_OK?
//        так -> готово; ні -> повторити DATA (до 3 разів)
//
// Якщо slave на кроці 3 ще зайнятий записом на SD, він не "озброєний" для
// SPI, і master бачить на MISO сміття. Таку відповідь master відкидає (не
// збігається MAGIC_RSP або CRC) і просто питає ще раз через 20 мс.
//
// ФОРМАТ КАДРУ ЗАПИТУ (master -> slave), завжди рівно FRAME_SIZE байтів:
//
//   байт:   0          1       2      3      4 .. 4+len-1     ...    63
//         +----------+------+-----+-----+-----------------+-----+------+
//         |MAGIC_REQ | type | seq | len |     payload     | 0.. | crc8 |
//         +----------+------+-----+-----+-----------------+-----+------+
//
//   MAGIC_REQ - ознака "це наш кадр" (відсікає шум/сміття)
//   type      - TYPE_DATA (записати payload) або TYPE_POLL (лише дай статус)
//   seq       - номер кадру 0..255 по колу; потрібен для підтвердження і
//               щоб slave не записав повтор двічі
//   len       - скільки байтів payload справжні (0..PAYLOAD_MAX)
//   payload   - самі дані (у нас текстовий рядок "ms,seq,temp\n")
//   0..       - невикористаний хвіст, заповнений нулями
//   crc8      - контрольна сума байтів 0..62
//
// ФОРМАТ КАДРУ ВІДПОВІДІ (slave -> master), також FRAME_SIZE байтів:
//
//   байт:   0          1          2        3           4..7        ...   63
//         +----------+----------+--------+-----------+-------------+-----+------+
//         |MAGIC_RSP | last_seq | status | bad_frames| total_bytes | 0.. | crc8 |
//         +----------+----------+--------+-----------+-------------+-----+------+
//
//   last_seq    - seq останнього кадру, який slave обробив (0xFF, якщо ще жодного)
//   status      - результат його обробки: ST_OK / ST_SD_ERR / ST_NONE
//   bad_frames  - лічильник отриманих кадрів з поганим magic/CRC (діагностика)
//   total_bytes - скільки байтів payload всього записано на SD (uint32, little-endian)
// ============================================================================
#pragma once
#include <stddef.h>
#include <stdint.h>

// Усі транзакції мають ОДНАКОВИЙ фіксований розмір. Це спрощує slave: він
// заздалегідь знає, скільки байтів прийняти, і не потребує розбору довжини.
constexpr size_t FRAME_SIZE = 64;

// Місце під payload: 64 мінус службові байти (magic, type, seq, len = 4
// на початку і crc = 1 в кінці).
constexpr size_t PAYLOAD_MAX = FRAME_SIZE - 5;

// Перший байт кадру: за ним відрізняємо справжній кадр від шуму на лінії
// або від "порожньої" відповіді, коли slave ще не готовий.
// Різні значення для запиту і відповіді - щоб не сплутати напрямки
// (наприклад, при короткому замиканні MOSI на MISO).
constexpr uint8_t MAGIC_REQ = 0xA5;  // 10100101
constexpr uint8_t MAGIC_RSP = 0x5A;  // 01011010 (інверсія A5)

// Типи кадрів запиту (байт [1]).
constexpr uint8_t TYPE_DATA = 1;  // payload треба записати на SD
constexpr uint8_t TYPE_POLL = 2;  // даних немає; потрібна лише відповідь зі статусом

// Коди статусу у відповіді (байт [2]).
constexpr uint8_t ST_OK = 0;       // кадр last_seq успішно записано на SD
constexpr uint8_t ST_SD_ERR = 1;   // кадр прийнято коректно, але запис на SD не вдався
constexpr uint8_t ST_NONE = 0xFF;  // slave ще не обробив жодного кадру

// CRC-8 (поліном x^8 + x^2 + x + 1, тобто 0x07, початкове значення 0).
// Ідея: рахуємо з усіх байтів "відбиток" в 1 байт. Передавач кладе його в
// кінець кадру, приймач рахує так само по отриманих даних і порівнює. Якщо
// хоч один біт спотворився в дорозі - значення майже напевно не збіжиться.
//   d - вказівник на байти, n - їх кількість
inline uint8_t crc8(const uint8_t* d, size_t n)
{
    uint8_t c = 0;
    while (n--) {
        c ^= *d++;  // підмішуємо наступний байт у поточне значення
        // Побітове "ділення в стовпчик" на поліном: 8 кроків на байт.
        for (int i = 0; i < 8; i++) {
            if (c & 0x80) {
                c = (uint8_t)((c << 1) ^ 0x07);  // старший біт 1: зсув і віднімання полінома
            } else {
                c = (uint8_t)(c << 1);           // старший біт 0: просто зсув
            }
        }
    }
    return c;
}
